# IAR project lwpa.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $MQX_BOARD_DIR$\debug\bsp; $MQX_BOARD_DIR$\debug\psp; $MQX_BOARD_DIR$\debug\; $MQX_BOARD_DIR$\debug\bsp\Sources; $MQX_BOARD_DIR$\debug\bsp\Generated_Code; $MQX_BOARD_DIR$\debug\rtcs; ..\..\..\include; ..\..\..\include\MQX
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  postbuild: cmd /c mkdir "..\..\..\lib\mqx\iar" & copy "debug\lwpa.a" "..\..\..\lib\mqx\iar\liblwpad.a"
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $MQX_BOARD_DIR$\release\bsp; $MQX_BOARD_DIR$\release\psp; $MQX_BOARD_DIR$\release\; $MQX_BOARD_DIR$\release\bsp\Sources; $MQX_BOARD_DIR$\release\bsp\Generated_Code; $MQX_BOARD_DIR$\release\rtcs; ..\..\..\include; ..\..\..\include\MQX
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  postbuild: cmd /c mkdir "..\..\..\lib\mqx\iar" & copy "release\lwpa.a" "..\..\..\lib\mqx\iar\liblwpa.a"
  group headers
    ../../../include/: acn_prot.h estardm.h estardmnet.h lwpa_bool.h lwpa_cid.h lwpa_common.h lwpa_error.h lwpa_inet.h lwpa_int.h lwpa_log.h lwpa_mempool.h lwpa_netint.h lwpa_pack.h lwpa_pdu.h lwpa_rbtree.h lwpa_rootlayerpdu.h lwpa_socket.h lwpa_timer.h lwpa_uid.h
    ../../../include/mqx/: lwpa_lock.h lwpa_socket_plat.h lwpa_thread.h
    ../../../src/: md5.h
  group sources
    ../../../src/: lwpa_cid.c lwpa_error.c lwpa_log.c lwpa_mempool.c lwpa_pdu.c lwpa_rbtree.c lwpa_rootlayerpdu.c lwpa_uid.c md5c.c
    ../../../src/mqx/: lwpa_lock.c lwpa_netint.c lwpa_socket.c lwpa_thread.c lwpa_timer.c
