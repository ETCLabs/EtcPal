# IAR project test_lwpa.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK61FN1M0xxx12 NXP MK61FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $MQX_BOARD_DIR$\debug\bsp; $MQX_BOARD_DIR$\debug\psp; $MQX_BOARD_DIR$\debug\; $MQX_BOARD_DIR$\debug\bsp\Sources; $MQX_BOARD_DIR$\debug\bsp\Generated_Code; $MQX_BOARD_DIR$\debug\rtcs; ..; ..\..\..\..\include; ..\..\..\..\include\mqx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $MQX_BOARD_DIR$/debug/bsp/intflash_ddrdata.icf
  ILINK.IlinkExtraOptions: --redirect MQX_init_struct=MY_MQX_init_struct
  ILINK.IlinkAdditionalLibs: $MQX_BOARD_DIR$/debug/bsp/bsp.a; $MQX_BOARD_DIR$/debug/psp/psp.a; $MQX_BOARD_DIR$/debug/rtcs/rtcs.a; ../../../../lib/mqx/iar/liblwpad.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $MQX_BOARD_DIR$\release\bsp; $MQX_BOARD_DIR$\release\psp; $MQX_BOARD_DIR$\release\; $MQX_BOARD_DIR$\release\bsp\Sources; $MQX_BOARD_DIR$\release\bsp\Generated_Code; $MQX_BOARD_DIR$\release\rtcs; ..; ..\..\..\..\include; ..\..\..\..\include\mqx
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: $MQX_BOARD_DIR$/release/bsp/bsp.a; $MQX_BOARD_DIR$/release/psp/psp.a; $MQX_BOARD_DIR$/release/rtcs/rtcs.a; ../../../../lib/mqx/iar/liblwpa.a
  group (top)
    ./: lwpatest.h main.c test_cid.c test_lock.c test_log.c test_mempool.c test_mutex.c test_netint.c test_pack.c test_rbtree.c test_rwlock.c test_signal.c test_socket.c test_thread.c test_timer.c
